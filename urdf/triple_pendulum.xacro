Commit message: Rename controllers.

File: urdf/triple_pendulum.xacro (robot description, xacro)
@@ -143,4 +143,5 @@
         velocity="3.0"
         effort="22.0" />
+      <dynamics damping="0.0" friction="0.0" />
     </joint>
     <!-- joint1 (cart -> pendulum1) -->
